# Keil uVision project STM32F302.uvprojx, settings and files
target master (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F302CBTx STMicroelectronics
  pack: Keil.STM32F3xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x00006000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F302 +hex
  AfterMake: .\create_bin.bat
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F303xC,USE_STDPERIPH_DRIVER
  c include: ..\device;..\libraries\STM32F30x_StdPeriph_Driver\inc;..\bsp;..\user;..\com;..\upgrade
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x6000
  group doc
    ../doc/: readme.txt
  group STM32F30x_StdPeriph_Driver
    ../libraries/STM32F30x_StdPeriph_Driver/src/: stm32f30x_adc.c stm32f30x_dma.c stm32f30x_flash.c stm32f30x_gpio.c stm32f30x_misc.c stm32f30x_rcc.c stm32f30x_spi.c stm32f30x_syscfg.c stm32f30x_tim.c stm32f30x_usart.c
  group device
    ../device/: startup_stm32f30x.s system_stm32f30x.c
  group user
    ../user/: main.c stm32f30x_it.c sys.c sys.h util.c param.c fw_version.c
  group bsp
    ../bsp/: delay.c led.c btn.c bat.c flash.c timebase.c port.c
  group com
    ../com/: uart1.c uart3.c uart1_tx.c uart3_tx.c uart1_parse.c uart3_parse.c fifo.c parse.c
  group upgrade
    ../upgrade/: upgrade.c
software components: CMSIS:CORE 4.3.0
